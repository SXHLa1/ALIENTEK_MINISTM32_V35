<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ALIENTEK_MINISTM32_V35.ewp</path>
  </project>
  <batchBuild />
</workspace>
